options:
  parameters:
    generate_options: qt_gui
    id: manual_tempest_example
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: DelaySyncDetector
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    orient: Qt.Horizontal
    start: '0'
    step: interpolatedHsize*1
    stop: Vsize*interpolatedHsize
    value: interpolatedHsize*1
  states: {}
- name: DroppedFrames
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: Hblank
  id: variable
  parameters:
    value: Hsize-Hvisible
  states: {}
- name: Hsize
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Horizontal resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(4096*1.5)
    value: '2600'
    widget: counter
  states: {}
- name: Hvisible
  id: variable
  parameters:
    value: '800'
  states: {}
- name: Vblank
  id: variable
  parameters:
    value: Vsize-Vvisible
  states: {}
- name: Vsize
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Vertical resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(2160*1.5)
    value: '1200'
    widget: counter
  states: {}
- name: Vvisible
  id: variable
  parameters:
    value: '600'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: 2**21
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Frequency slider
    orient: Qt.Horizontal
    start: 40e6
    step: 1e6
    stop: 5e9
    value: '206200000'
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: interpolatedHblank
  id: variable
  parameters:
    value: int(Hblank/float(px_rate)*samp_rate)
  states: {}
- name: interpolatedHscreen
  id: variable
  parameters:
    value: int(Hvisible/float(px_rate)*samp_rate)
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*samp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab_m@0
    label: Inverted colors?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '1'
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Refresh Rate (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '240'
    value: '60'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(50e6)
  states: {}
- name: FFT_autocorrelation_0_0
  id: FFT_autocorrelation
  parameters:
    alpha: '1.0'
    fft_size: int(fft_size)
  states: {}
- name: Keep_1_in_N_Frames_0
  id: Keep_1_in_N_Frames
  parameters:
    fac_decimation: DroppedFrames
    fft_size: interpolatedHsize*Vsize*4
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: DelaySyncDetector
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_m@1
    size: int(fft_size/2)
    srate: samp_rate
    tr_level: '15.0'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"peak_1"'
    type: float
    update_time: '2.0'
  states: {}
- name: ratio_finder_toggle_on_and_off
  id: tempest_tempest_msgbtn
  parameters:
    label: Ratio Finder Toggle ON or OFF (FFT peaks)
    msgName: pressed
    relBackgroundColor: default
    relFontColor: default
    type: bool
    value: 'True'
  states: {}
- name: tab_m
  id: qtgui_tab_widget
  parameters:
    label0: Tempest Main Tab
    label1: Autocorrelation Plot Tab
    num_tabs: '2'
  states: {}
- name: tempest_fft_peak_fine_sampling_sync_0_0
  id: tempest_fft_peak_fine_sampling_sync
  parameters:
    Hvisible: interpolatedHsize
    Vvisible: Vsize
    automatic_mode: 'True'
    refresh_rate: refresh_rate
    sample_rate: samp_rate
    size: int(fft_size)
  states: {}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: tempest_sync_detector_0_0
  id: tempest_sync_detector
  parameters:
    hblanking: interpolatedHblank
    hscreen: interpolatedHscreen
    vblanking: Vblank
    vscreen: Vsize-Vblank
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: px_rate*harmonic
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '"recv_frame_size= 65536, num_recv_frames=128"'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq_slider
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '"recv_frame_size= 65536, num_recv_frames=128"'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: '1080'
    display_width: '1920'
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {}

connections:
- [FFT_autocorrelation_0_0, '0', tempest_fft_peak_fine_sampling_sync_0_0, '0']
- [Keep_1_in_N_Frames_0, '0', FFT_autocorrelation_0_0, '0']
- [Keep_1_in_N_Frames_0, '0', tempest_sync_detector_0_0, '0']
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0_0_0, '0']
- [ratio_finder_toggle_on_and_off, pressed, tempest_fft_peak_fine_sampling_sync_0_0, en]
- [tempest_fft_peak_fine_sampling_sync_0_0, '0', qtgui_time_sink_x_1, '0']
- [tempest_fft_peak_fine_sampling_sync_0_0, en, FFT_autocorrelation_0_0, en]
- [tempest_fft_peak_fine_sampling_sync_0_0, en, tempest_sync_detector_0_0, en]
- [tempest_fft_peak_fine_sampling_sync_0_0, rate, uhd_usrp_source_0, command]
- [tempest_fft_peak_fine_sampling_sync_0_0, rate, uhd_usrp_source_0_0, command]
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0, '0']
- [tempest_sync_detector_0_0, '0', blocks_delay_0_0, '0']
- [uhd_usrp_source_0, '0', Keep_1_in_N_Frames_0, '0']
- [uhd_usrp_source_0_0, '0', Keep_1_in_N_Frames_0, '0']

metadata:
  file_format: 1

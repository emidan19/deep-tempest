options:
  parameters:
    generate_options: qt_gui
    id: manual_tempest_example
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: DroppedFrames
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: Hblank
  id: variable
  parameters:
    value: Hsize-Hvisible
  states: {}
- name: Hsize
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Horizontal resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(4096*1.5)
    value: '1800'
    widget: counter
  states: {}
- name: Hvisible
  id: variable
  parameters:
    value: '1600'
  states: {}
- name: UHD_gain
  id: variable_qtgui_range
  parameters:
    label: UHD Gain
    orient: Qt.Horizontal
    start: '10'
    step: '10'
    stop: '100'
    value: '50'
  states: {}
- name: Vblank
  id: variable
  parameters:
    value: Vsize-Vvisible
  states: {}
- name: Vsize
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Vertical resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(2160*1.5)
    value: '1000'
    widget: counter
  states: {}
- name: Vvisible
  id: variable
  parameters:
    value: '900'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: 2**21
  states: {}
- name: fine_phase
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Frequency error
    orient: Qt.Horizontal
    start: '-pi/4'
    step: pi/10000
    stop: pi/4
    value: '0'
  states: {}
- name: freq_error
  id: variable
  parameters:
    value: (samp_rate*fine_phase)/(2*pi*interpolatedHsize)
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '3'
  states: {}
- name: interpolatedHblank
  id: variable
  parameters:
    value: int(Hblank/float(px_rate)*samp_rate)
  states: {}
- name: interpolatedHscreen
  id: variable
  parameters:
    value: int(Hvisible/float(px_rate)*samp_rate)
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*samp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab_m@0
    label: Inverted colors?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option0: '-1'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '1'
    widget: radio_buttons
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: ratio_correct
  id: variable
  parameters:
    value: (1.0/(1+0.000935))
  states: {}
- name: refresh_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@0
    label: Refresh Rate (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '240'
    value: '60'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(50e6)
  states: {}
- name: FFT_autocorrelation_0_0
  id: FFT_autocorrelation
  parameters:
    alpha: '1.0'
    fft_size: int(fft_size)
  states: {}
- name: Keep_1_in_N_Frames_0
  id: Keep_1_in_N_Frames
  parameters:
    comment: |-
      Drop entire frames samples
      given the image resolution
    fac_decimation: DroppedFrames
    fft_size: interpolatedHsize*Vsize*4
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      Create sinusoidal signal
      with estimated error
      frequency
    sensitivity: '-1/(interpolatedHsize)'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      Multiply by sinusoidal 
      to fix frequency error
      manually
    freq: '-freq_error'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    comment: Visualize image with in-phase samples
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: interpolatedHsize
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: interpolatedHsize*10
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Plot the phase error
    grid: 'True'
    gui_hint: tab_m@0
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.5'
    ylabel: Phase difference (rad).
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: Plots autocorrelation of captured signal
    grid: 'True'
    gui_hint: tab_m@1
    size: int(fft_size/2)
    srate: samp_rate
    tr_level: '20.0'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"peak_1"'
    type: float
    update_time: '3.0'
  states: {}
- name: tab_m
  id: qtgui_tab_widget
  parameters:
    label0: Tempest Main Tab
    label1: Autocorrelation Plot Tab
    num_tabs: '2'
  states: {}
- name: tempest_buttonToFileSink_0
  id: tempest_buttonToFileSink
  parameters:
    Filename: /home/emidan19/Desktop/capture
    H_size: Hsize
    V_size: Vsize
    comment: |-
      Saves the captured image
      Enable enhancement to apply
      deep-tempest module

      NOTE:
      Specify image saving path
    enhance_image: 'False'
    input_width: interpolatedHsize
    remove_blanking: 'True'
  states: {}
- name: tempest_fft_peak_fine_sampling_sync_0_0
  id: tempest_fft_peak_fine_sampling_sync
  parameters:
    Hvisible: interpolatedHsize
    Vvisible: Vsize
    automatic_mode: 'True'
    refresh_rate: int(refresh_rate)
    sample_rate: samp_rate
    size: int(fft_size)
  states: {}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: tempest_screenshot
  id: tempest_tempest_msgbtn
  parameters:
    comment: Triggers screenshot
    gui_hint: tab_m@0
    label: Take screenshot
    msgName: pressed
    relBackgroundColor: default
    relFontColor: default
    type: bool
    value: 'True'
  states: {}
- name: tempest_tempest_msgbtn_0
  id: tempest_tempest_msgbtn
  parameters:
    comment: |-
      Triggers sample correction
      with computed ratio
    gui_hint: tab_m@0
    label: 'Adjust image (sampling ratio finder). '
    msgName: pressed
    relBackgroundColor: default
    relFontColor: default
    type: bool
    value: 'True'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: px_rate*harmonic
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '"recv_frame_size= 65536, num_recv_frames=128"'
    gain0: UHD_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: Vsize
    display_width: Hsize
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {}

connections:
- [FFT_autocorrelation_0_0, '0', tempest_fft_peak_fine_sampling_sync_0_0, '0']
- [Keep_1_in_N_Frames_0, '0', FFT_autocorrelation_0_0, '0']
- [Keep_1_in_N_Frames_0, '0', blocks_delay_1, '0']
- [Keep_1_in_N_Frames_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [Keep_1_in_N_Frames_0, '0', blocks_multiply_xx_0_0, '2']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_arg_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_float_to_short_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0_0, '0', tempest_buttonToFileSink_0, '0']
- [tempest_fft_peak_fine_sampling_sync_0_0, '0', qtgui_time_sink_x_1, '0']
- [tempest_fft_peak_fine_sampling_sync_0_0, rate, uhd_usrp_source_0, command]
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0, '0']
- [tempest_screenshot, pressed, tempest_buttonToFileSink_0, en]
- [tempest_tempest_msgbtn_0, pressed, tempest_fft_peak_fine_sampling_sync_0_0, en]
- [uhd_usrp_source_0, '0', Keep_1_in_N_Frames_0, '0']

metadata:
  file_format: 1

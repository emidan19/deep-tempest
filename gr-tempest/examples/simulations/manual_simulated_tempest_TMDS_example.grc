options:
  parameters:
    generate_options: qt_gui
    id: manual_simulated_tempest_TMDS_example
    output_language: python
    title: Manual  Simulated Tempest TMDS Example
  states: {}

blocks:
- name: Hdisplay
  id: variable
  parameters:
    value: Hsize
  states: {}
- name: Hsize
  id: variable
  parameters:
    value: '2200'
  states: {}
- name: Hvisible
  id: variable
  parameters:
    value: '1920'
  states: {}
- name: Vdisplay
  id: variable
  parameters:
    value: Vsize
  states: {}
- name: Vsize
  id: variable
  parameters:
    value: '1125'
  states: {}
- name: Vvisible
  id: variable
  parameters:
    value: '1080'
  states: {}
- name: decim
  id: variable
  parameters:
    value: inter
  states: {}
- name: epsilon_channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sampling error
    orient: Qt.Horizontal
    start: '-0.1'
    step: '10e-6'
    stop: '0.1'
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency Error (normalized)
    orient: Qt.Horizontal
    start: '-1'
    step: '1e-5'
    stop: '1'
    value: '0'
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Horizontal offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: interpolatedHsize
    value: '0'
  states: {}
- name: inter
  id: variable
  parameters:
    value: '10'
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*usrp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: Inverted colors?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '1'
    widget: radio_buttons
  states: {}
- name: lines_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Vertical offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Vsize
    value: int(Vsize/2)
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Noise Power
    orient: Qt.Horizontal
    start: '0'
    step: '1e-3'
    stop: '2'
    value: '0'
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate/100
  states: {}
- name: rectangular_pulse
  id: variable
  parameters:
    value: '[0.7/255]*inter'
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(px_rate*inter)
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: int(50e6/100)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '4'
    freq: px_rate*harmonic
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: binary_serializer_0
  id: binary_serializer
  parameters:
    M: '10'
    N: '16'
    offset: '0'
  states: {}
- name: binary_serializer_0_0
  id: binary_serializer
  parameters:
    M: '10'
    N: '16'
    offset: '0'
  states: {}
- name: binary_serializer_0_0_0
  id: binary_serializer
  parameters:
    M: '10'
    N: '16'
    offset: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: interpolatedHsize*lines_offset+horizontal_offset
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon_channel+1
    freq_offset: freq
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: genero la forma de onda en el cable
    interp: inter
    taps: rectangular_pulse
    type: fcc
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    fbw: '0.4'
    interp: usrp_rate
    taps: ''
    type: ccc
  states: {}
- name: tempest_TMDS_image_source_0
  id: tempest_TMDS_image_source
  parameters:
    blanking: 'True'
    image_file: /home/emidan19/Desktop/deep-tempest/drunet/notebooks/images/mattermost_screen.png
    mode: '1'
  states: {}
- name: tempest_buttonToFileSink_0
  id: tempest_buttonToFileSink
  parameters:
    Filename: /home/emidan19/Desktop/captura_simulada_shiftfix
    H_size: Hsize
    V_size: Vsize
    enhance_image: 'True'
    input_width: interpolatedHsize
  states: {}
- name: tempest_fine_sampling_synchronization_0
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    correct_sampling: '1'
    max_deviation: 100.0/interpolatedHsize
    update_proba: 1.0/(interpolatedHsize*Vsize)
  states: {}
- name: tempest_framing_0
  id: tempest_framing
  parameters:
    Hdisplay: Hdisplay
    Htotal: interpolatedHsize
    Vdisplay: Vdisplay
    Vtotal: Vsize
  states: {state: disabled}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: tempest_tempest_msgbtn_0
  id: tempest_tempest_msgbtn
  parameters:
    label: Take screenshot
    msgName: pressed
    relBackgroundColor: default
    relFontColor: default
    type: bool
    value: 'True'
  states: {}
- name: video_sdl_sink_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are not sure what the 
      resolution is and you want to try several ones 
      on run-time. Then, enable the other path.
    display_height: Vdisplay
    display_width: Hdisplay
    fps: '0'
    height: Vdisplay
    type: short
    width: Hdisplay
  states: {state: disabled}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: Vsize
    display_width: Hsize
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [binary_serializer_0, '0', blocks_add_xx_0, '0']
- [binary_serializer_0_0, '0', blocks_add_xx_0, '1']
- [binary_serializer_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_complex_to_float_0, '0', tempest_normalize_flow_0, '0']
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_float_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_delay_0, '0', tempest_buttonToFileSink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_float_to_short_0_0, '0', video_sdl_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', tempest_fine_sampling_synchronization_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0_0, '0']
- [rational_resampler_xxx_0, '0', channels_channel_model_0, '0']
- [tempest_TMDS_image_source_0, '0', binary_serializer_0, '0']
- [tempest_TMDS_image_source_0, '1', binary_serializer_0_0, '0']
- [tempest_TMDS_image_source_0, '1', blocks_null_sink_0, '0']
- [tempest_TMDS_image_source_0, '2', binary_serializer_0_0_0, '0']
- [tempest_TMDS_image_source_0, '2', blocks_null_sink_0, '1']
- [tempest_fine_sampling_synchronization_0, '0', blocks_delay_0, '0']
- [tempest_framing_0, '0', blocks_float_to_short_0_0, '0']
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0, '0']
- [tempest_normalize_flow_0, '0', tempest_framing_0, '0']
- [tempest_tempest_msgbtn_0, pressed, tempest_buttonToFileSink_0, en]

metadata:
  file_format: 1

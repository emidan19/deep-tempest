options:
  parameters:
    generate_options: qt_gui
    id: example_buttonToFileSink
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tempest_buttonToFileSink_0
  id: tempest_buttonToFileSink
  parameters:
    Filename: /home/gnuradio/persistent/deep-tempest/images/capture_test
    H_size: '800'
    V_size: '600'
  states: {}
- name: tempest_image_source_0
  id: tempest_image_source
  parameters:
    Htotal: '800'
    Hvisible: '800'
    Vtotal: '600'
    Vvisible: '600'
    image_file: /home/gnuradio/persistent/deep-tempest/gr-tempest/Imagen_800_600.png
    repeatmode: '1'
  states: {}
- name: tempest_tempest_msgbtn_0
  id: tempest_tempest_msgbtn
  parameters:
    label: Take screenshot
    msgName: pressed
    relBackgroundColor: default
    relFontColor: default
    type: bool
    value: 'True'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', tempest_buttonToFileSink_0, '0']
- [tempest_image_source_0, '0', blocks_float_to_complex_0, '0']
- [tempest_tempest_msgbtn_0, pressed, tempest_buttonToFileSink_0, en]

metadata:
  file_format: 1
  grc_version: 3.10.5.1

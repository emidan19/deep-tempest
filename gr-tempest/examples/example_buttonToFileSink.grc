options:
  parameters:
    generate_options: qt_gui
    id: example_buttonToFileSink
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 50e6
    type: complex
  states: {}
- name: tempest_TMDS_image_source_0
  id: tempest_TMDS_image_source
  parameters:
    blanking: 'True'
    image_file: /home/emidan19/deep-tempest/images/1920x1080_test.png
    mode: '2'
  states: {}
- name: tempest_buttonToFileSink_0
  id: tempest_buttonToFileSink
  parameters:
    Filename: /home/emidan19/deep-tempest/gr-tempest/captura
    H_size: '2200'
    V_size: '1125'
  states: {}
- name: tempest_tempest_msgbtn_0
  id: tempest_tempest_msgbtn
  parameters:
    label: Take screenshot
    msgName: pressed
    relBackgroundColor: default
    relFontColor: default
    type: bool
    value: 'True'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', tempest_buttonToFileSink_0, '0']
- [tempest_TMDS_image_source_0, '0', blocks_float_to_complex_0, '0']
- [tempest_TMDS_image_source_0, '1', blocks_float_to_complex_0, '1']
- [tempest_TMDS_image_source_0, '2', blocks_null_sink_0, '0']
- [tempest_tempest_msgbtn_0, pressed, tempest_buttonToFileSink_0, en]

metadata:
  file_format: 1

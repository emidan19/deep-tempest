options:
  parameters:
    author: Emilio Martinez
    category: '[Tempest]'
    description: Serializes every input as LSB stream of bits
    generate_options: hb
    id: binary_serializer
    output_language: python
    run: 'False'
    title: Binary Serializer
  states: {}

blocks:
- name: M
  id: parameter
  parameters:
    label: Output bits
    type: intx
    value: '10'
  states: {}
- name: N
  id: parameter
  parameters:
    label: Input bits
    type: intx
    value: '16'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: M
    n: N
    offset: offset
    type: short
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: offset
  id: parameter
  parameters:
    label: Offset position (from LSB)
    type: intx
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_float_to_short_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_short_to_float_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_short_to_float_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_float_to_short_0, '0']

metadata:
  file_format: 1

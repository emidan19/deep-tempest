options:
  parameters:
    generate_options: no_gui
    id: NO_GUI_tempest_simulated_TMDS
    output_language: python
    title: Manual  Simulated Tempest TMDS Example
  states: {}

blocks:
- name: Hsize
  id: variable
  parameters:
    value: '1056'
  states: {}
- name: Hvisible
  id: variable
  parameters:
    value: '800'
  states: {}
- name: Vsize
  id: variable
  parameters:
    value: '628'
  states: {}
- name: Vvisible
  id: variable
  parameters:
    value: '600'
  states: {}
- name: harmonic
  id: variable
  parameters:
    value: '3'
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10*px_rate)
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: int(50e6)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      Bajar a bandabase
      cierto armónico
    freq: px_rate*harmonic
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: binary_serializer_0
  id: binary_serializer
  parameters:
    M: '10'
    N: '16'
    offset: '0'
  states: {}
- name: binary_serializer_0_0
  id: binary_serializer
  parameters:
    M: '10'
    N: '16'
    offset: '0'
  states: {}
- name: binary_serializer_0_0_0
  id: binary_serializer
  parameters:
    M: '10'
    N: '16'
    comment: |-
      Serializar cada
      pixel codificado
    offset: '0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Hacer que los bits valgan
      -1 o 1 para cada canal
    const: '3'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: |-
      Superposición de
       canales
      (captación 
      de antena)
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: tempest_TMDS_image_source_0
  id: tempest_TMDS_image_source
  parameters:
    comment: |-
      Levantar imagen y 
      codificarla TMDS
    image_file: /home/emidan19/Desktop/deep-tempest/Codigo Menoni Octave/black_cube_800x600.jpg
    mode: '3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [binary_serializer_0, '0', blocks_add_xx_0, '0']
- [binary_serializer_0_0, '0', blocks_add_xx_0, '1']
- [binary_serializer_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_null_sink_0, '0']
- [tempest_TMDS_image_source_0, '0', binary_serializer_0, '0']
- [tempest_TMDS_image_source_0, '1', binary_serializer_0_0, '0']
- [tempest_TMDS_image_source_0, '2', binary_serializer_0_0_0, '0']

metadata:
  file_format: 1
